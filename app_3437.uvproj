# Keil uVision project app_3437.uvproj, settings and files
target Target1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: SBOM_bk3437_app +hex (library)
  AfterMake: fromelf --bin --output .\output\app\bk3437_app.bin .\obj\bk3437_app.axf
  AfterMake: .\output\translate.bat
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: CFG_CPU_BK3633 USE_PWM_DIFF USE_ADC0
  c misc: --gnu
  c include: ..\..\src\ip\ble\ll\api;..\..\src\ip\ble\ll\import\reg;..\..\src\ip\ble\ll\src;..\..\src\ip\bt\api;..\..\src\ip\bt\import\reg;..\..\src\ip\bt\src;..\..\src\ip\em\api;..\..\src\ip\hci\api;..\..\src\ip\sch\api;..\..\src\ip\sch\import;..\..\src\modules\aes\api;..\..\src\modules\common\api;..\..\src\modules\dbg\api;..\..\src\modules\ecc_p256\api;..\..\src\modules\h4tl\api;..\..\src\modules\ke\api;..\..\src\plf\nvds\api;..\..\src\driver\rf;..\..\src\plf\rwip\api;..\..\src\plf\rwip\import\reg;..\..\src\plf\refip\import\reg;..\..\src\plf\refip\src\arch;..\..\src\plf\refip\src\arch\boot\rvds;..\..\src\plf\refip\src\arch\compiler\rvds;..\..\src\plf\refip\src\arch\ll\rvds;..\..\src\driver\flash;..\..\src\driver\led;..\..\src\driver\reg;..\..\src\driver\syscntl;..\..\src\driver\timer;..\..\src\driver\uart;..\..\src\driver\uart2;..\..\Src\header;..\..\Src\header\header_file;..\..\Src\plf\refip\src\driver;..\..\Src\ip\ble\hl\api;..\..\Src\ip\ble\hl\inc;..\..\Src\ip\ble\hl\src\gap\gapc;..\..\Src\ip\ble\hl\src\gap\gapm;..\..\Src\ip\ble\hl\src\gatt;..\..\Src\ip\ble\hl\src\gatt\attc;..\..\Src\ip\ble\hl\src\gatt\attm;..\..\Src\ip\ble\hl\src\gatt\atts;..\..\Src\ip\ble\hl\src\gatt\gattc;..\..\Src\ip\ble\hl\src\gatt\gattm;..\..\Src\ip\ble\hl\src\l2c\l2cc;..\..\Src\ip\ble\hl\src\l2c\l2cm;..\..\Src\app\api;..\..\Src\profiles\dis\diss\api;..\..\Src\profiles\FEE0\api;..\..\Src\profiles\bas\bass\api;..\..\Src\profiles\FCC0_128\api;..\..\Src\driver\gpio;..\..\Src\driver\spi;..\..\Src\driver\icu;..\..\Src\driver\wdt;..\..\Src\driver\adc;..\..\Src\profiles\ancs\ancsc\api;..\..\Src\profiles\oad\api;..\..\Src\profiles\ancs\ancsc;.\config;.\app\api;..\..\src\driver\aon_rtc;..\..\src\plf\prf;..\..\src\plf\beken\src\driver\intc;..\..\src\driver\dma;..\..\src\plf\beken\src\driver\i2c;..\..\src\device\lcd;..\..\src\profiles\hogp\hogpd\api;..\..\src\profiles\hogp;..\..\src\plf\beken\src\arch\main;..\..\src\plf\beken\src\arch\compiler\armgcc;..\..\src\plf\beken\src\arch;..\..\src\plf\beken\src\arch\ll\armgcc;..\..\src\modules\rwip\api;..\..\src\plf\beken\src\driver\reg;..\..\src\plf\beken\src\driver\uart;..\..\src\plf\beken\src\rf\api;.\config;..\..\src\modules\rwip\src;..\..\src\plf\beken\src\driver\icu;..\..\src\plf\beken\src\driver\uart0;..\..\src\plf\beken\src\driver\uart1;..\..\src\plf\beken\src\driver\uart2;..\..\src\profiles\oad\api;..\..\src\plf\beken\src\driver\adc;..\..\src\plf\beken\src\driver\gpio;..\..\src\plf\beken\src\driver\opus;..\..\src\plf\beken\src\driver\aud;..\..\src\plf\beken\src\driver\flash;..\..\src\plf\beken\src\driver\opus;..\..\src\plf\beken\src\driver\wdt;..\..\src\config;..\..\src\ip\ble\hl\config;..\..\src\plf\beken\src\driver\opus;..\..\src\plf\beken\src\arch\boot\rvds;..\..\src\ip\ble\hl\src\inc;..\..\src\ip\ble\iso\data_path;..\..\src\lib;..\..\src\ip\ble\hl\api;..\..\src\plf\beken\src\driver\aon_rtc;..\..\src\plf\beken\src\driver\timer0;..\..\src\plf\beken\src\driver\spi;..\..\src\plf\beken\src\driver\dma;..\..\src\plf\beken\src\driver\i2s;..\..\src\plf\util;..\..\src\plf\beken\src\driver\rgb;.\user;..\..\src\plf\beken\src\driver\pwm
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x400000 size 0x10000
  scatter file: ..\..\src\system\peripheral_app_link.txt
  link misc: --entry sys_Reset
  group system
    ../../src/system/: boot_handlers.s boot_vectors.s peripheral_stack_symbol.txt
    ./app/src/: main.c
  group app
    ./app/src/: app.c app_batt.c app_dis.c app_fee0.c app_oads.c app_sec.c app_task.c app_auto_test.c
  group plf
    ../../Src/plf/rwip/src/: rwble.c rwip.c
    ../../Src/plf/nvds/src/: nvds.c
    ../../src/plf/prf/: prf_utils.c prf.c
    ../../src/plf/rwip/src/: rwbt.c
    ../../src/plf/util/: util_encrypt.c
  group driver
    ../../src/plf/beken/src/driver/intc/: intc.c
    ../../src/plf/beken/src/rf/src/: rf_xvr.c
    ../../src/plf/beken/src/driver/uart0/: uart0_initial.c
    ../../src/plf/beken/src/driver/uart1/: uart1_initial.c
    ../../src/plf/beken/src/driver/uart/: uart.c
    ../../src/plf/beken/src/driver/flash/: driver_flash.c
    ../../src/plf/beken/src/driver/wdt/: wdt.c
    ../../src/plf/beken/src/driver/gpio/: driver_gpio.c
    ../../src/plf/beken/src/driver/icu/: icu.c
    ../../src/plf/beken/src/data_path/: plf_data_path.c
    ../../src/plf/beken/src/arch/main/: arch_main.c
    ../../src/plf/beken/src/driver/aon_rtc/: aon_rtc.c
    ../../src/plf/beken/src/driver/adc/: adc.c
    ../../src/plf/beken/src/driver/timer0/: timer0.c
    ../../src/plf/beken/src/driver/spi/: spi.c spi_dma.c
    ../../src/plf/beken/src/driver/rgb/: spi_to_rgb_tc1903.c spi_to_rgb_ws2812.c
    ../../src/plf/beken/src/driver/dma/: dma.c
    ../../src/plf/beken/src/driver/i2s/: i2s.c
    ../../src/plf/beken/src/driver/pwm/: pwm.c
  group profiles
    ../../Src/profiles/dis/diss/src/: diss.c
    ../../Src/profiles/FEE0/src/: fee0s.c
    ../../Src/profiles/bas/bass/src/: bass.c
    ../../Src/profiles/oad/src/: oads.c
    ../../src/profiles/oad/src/: oads_common.c
  group config
    ./config/: rwapp_config.h user_config.h rwip_config.h
  group lib
    ../../src/lib/: app_code_encrypt.lib
  group utils
    ../../src/plf/util/: bk_printf.c
  group user
    ./user/: bsp.c
